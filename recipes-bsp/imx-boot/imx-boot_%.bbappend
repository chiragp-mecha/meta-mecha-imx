UBOOT_DTB_NAME="mecha-comet.dtb"